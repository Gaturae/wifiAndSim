# Keil uVision project ireead.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 wLevel=1
  c define: STM32F10X_HD
  c include: .\src\ATK-ESP8266;.\src\FATFS\exfuns;.\src\FATFS\src;.\src\FATFS\src\option;.\src\HARDWARE\24CXX;.\src\HARDWARE\FLASH;.\src\HARDWARE\KEY;.\src\HARDWARE\LCD;.\src\HARDWARE\LED;.\src\HARDWARE\SD;.\src\HARDWARE\SPI;.\src\HARDWARE\TIMER;.\src\HARDWARE\TOUCH;.\src\HARDWARE\USART2;.\src\MALLOC;.\src\SYSTEM\delay;.\src\SYSTEM\sys;.\src\SYSTEM\usart;.\src\TEXT;.\src\USMART
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./src/user/: startup_stm32f10x_hd.s
  group USER
    ./src/USER/: main.c
  group SYSTEM
    ./src/SYSTEM/delay/: delay.c
    ./src/SYSTEM/sys/: sys.c
    ./src/SYSTEM/usart/: usart.c
  group HARDWARE
    ./src/HARDWARE/24CXX/: 24cxx.c myiic.c
    ./src/HARDWARE/KEY/: key.c
    ./src/HARDWARE/FLASH/: flash.c
    ./src/HARDWARE/LCD/: ILI93xx.c
    ./src/HARDWARE/LED/: led.c
    ./src/HARDWARE/SD/: MMC_SD.C
    ./src/HARDWARE/SPI/: spi.c
    ./src/HARDWARE/TOUCH/: ctiic.c ft5206.c gt9147.c ott2001a.c touch.c
    ./src/HARDWARE/USART2/: usart2.c
  group USMART
    ./src/USMART/: usmart.c usmart_config.c usmart_str.c
  group FATFS
    ./src/FATFS/exfuns/: exfuns.c fattester.c mycc936.c
    ./src/FATFS/src/: diskio.c ff.c
  group TEXT
    ./src/TEXT/: fontupd.c text.c
  group ATK_ESP8266
    ./src/ATK-ESP8266/: apsta.c common.c wifiap.c wifista.c
  group MALLOC
    ./src/MALLOC/: malloc.c
  group README
    ./src/: README.TXT
